# Keil uVision project nRF_interrupt.uvprojx, settings and files
target nRF51 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: example_01 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BSP_DEFINES_ONLY BOARD_PCA10001 NRF51
  asm define: BSP_DEFINES_ONLY BOARD_PCA10001 NRF51
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./: main.c
software components: CMSIS:CORE 5.0.0, Board Support:bsp 11.0.0-2.alpha, Device:Startup 8.6.0, nRF_Drivers:nrf_gpio 4.0.0-2.alpha
